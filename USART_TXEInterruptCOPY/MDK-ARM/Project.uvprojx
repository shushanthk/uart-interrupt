# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: HK32F0301MG6P7A HK_MicroChip
  pack: HKMicroChip.HK32F030xMxx_DFP.1.0.17
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: HK32F0301MG6P7A,HK32F0301MXXA,USE_HK32F0301MG6P7A_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: ..\..\..\..\..\Libraries\CMSIS\CM0\Core;..\..\..\..\..\Libraries\CMSIS\HK32F030xMxxA\Include;..\..\..\..\..\Libraries\CMSIS\HK32F030xMxxA\Source\ARM;..\..\..\..\..\Libraries\CMSIS\HK32F030xMxxA\Source;..\..\..\..\..\Libraries\CMSIS\HK32F030xMxxA\Include;..\..\..\..\..\Libraries\HK32F030xMxxA_StdPeriph_Driver\inc;..\..\..\..\..\Libraries\HK32F030xMxxA_StdPeriph_Driver\src;..\inc;..\src;..\..\..\..\..\Boards\Board_HK32F0301MG6P7A_EVAL\inc;..\..\..\..\..\Boards\Board_HK32F0301MG6P7A_EVAL\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../Libraries/CMSIS/HK32F030xMxxA/Source/: system_hk32f030xmxxa.c
    ../../../../../Libraries/CMSIS/HK32F030xMxxA/Source/ARM/: KEIL_Startup_hk32f030xmxxa.s
  group User
    ../src/: hk32f030xmxxa_it.c main.c
  group StdPeriph_Driver
    ../../../../../Libraries/HK32F030xMxxA_StdPeriph_Driver/src/: hk32f030xmxxa_dbgmcu.c hk32f030xmxxa_exti.c hk32f030xmxxa_flash.c hk32f030xmxxa_gpio.c hk32f030xmxxa_misc.c hk32f030xmxxa_pwr.c hk32f030xmxxa_rcc.c hk32f030xmxxa_syscfg.c hk32f030xmxxa_usart.c
